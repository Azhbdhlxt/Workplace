# Keil uVision project 字符LCD.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 字符LCD +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c LCD1602.c Delay.h Delay.c
    ../../../STM32入门教程资料等多个文件/51单片机入门教程资料/课件及程序源码/程序源码/LCD1602驱动代码/: LCD1602.h
