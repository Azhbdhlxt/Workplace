# Keil uVision project 矩阵键盘.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: 矩阵键盘 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c Delay.c Delay.h LCD1602.c LCD1602.h MatrixKey.c MatrixKey.h IndependentKey.c IndependentKey.h
